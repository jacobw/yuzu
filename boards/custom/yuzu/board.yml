## boards/custom/yuzu/board.yml
```yaml
board:
  name: yuzu
  full_name: Yuzu
  vendor: custom
  socs:
    - name: nrf52840
```
